!Keysight Technologies,N5245B,MY52451815,A.15.70.20
!Date: Thursday, April 18, 2024 11:17:03
!Correction: S33(C  2-Port  )
!S43(C  2-Port  )
!S34(C  2-Port  )
!S44(C  2-Port  )
!S2P File: Measurements: S33, S43, S34, S44:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -38.55 dB at 39.18 GHz (marker M1); lowest = -107.1 dB at 1.14 GHz (marker M2)
!   lowest |S11| = -38.4 dB at 25.48 GHz (marker M3), VSWR 1.02, Z = 51.1 - j0.431 ohm
!   |S11| at or under -10 dB: 8.372 GHz to 10.45 GHz (2.076 GHz wide, 22.1 % of centre); 12.04 GHz to 14.65 GHz (2.615 GHz wide, 19.6 % of centre); 15.18 GHz to 16.17 GHz (990.8 MHz wide, 6.32 % of centre) (the widest 3 of 17)
!   |S22| runs from -27.7 to 0.8 dB; largest |S21 - S12| = 0.018
!   the Smith chart shows 24.31 GHz to 26.76 GHz only
!   S11 on the Smith chart (normalised r, x): 24.31 GHz: 0.88, -0.12; 24.78 GHz: 0.98, -0.81; 25.27 GHz: 1.79, +0.19; 25.7 GHz: 0.67, -0.28; 26.16 GHz: 0.79, -1.20; 26.76 GHz: 1.39, -0.33
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.8  -52.7  -51.8  -0.5
! 1.14 GHz  -1.1  -107.1  -76.7  -0.7
! 6.68 GHz  -5.9  -72.0  -69.1  -1.5
! 13.34 GHz  -22.4  -64.6  -65.6  -4.9
! 16.78 GHz  -14.6  -59.3  -66.7  -3.4
! 18.8 GHz  -5.8  -62.9  -65.5  -21.6
! 20.01 GHz  -7.1  -74.6  -62.5  -7.4
! 20.71 GHz  -21.6  -61.9  -65.4  -2.6
! 21.19 GHz  -10.4  -60.6  -67.1  -3.2
! 21.87 GHz  -22.8  -70.7  -65.1  -3.0
! 24.31 GHz  -20.6  -58.8  -64.2  -10.9
! 24.78 GHz  -8.5  -60.8  -58.0  0.3
! 25.27 GHz  -10.8  -65.4  -61.5  -12.1
! 25.48 GHz  -38.4  -54.9  -54.5  -8.3
! 25.7 GHz  -12.0  -68.8  -60.0  -1.7
! 26.16 GHz  -5.0  -58.5  -65.8  -4.1
! 26.67 GHz  -10.3  -62.5  -56.5  -3.2
! 26.76 GHz  -13.4  -58.4  -58.7  -1.8
! 33.34 GHz  -3.9  -56.2  -52.7  -4.0
! 34.76 GHz  -2.1  -49.7  -72.0  -27.7
! 39.18 GHz  -4.4  -38.6  -70.2  0.3
! 40 GHz  0.1  -39.6  -38.3  -2.8
