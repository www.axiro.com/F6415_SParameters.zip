!Keysight Technologies,N5245B,MY52451815,A.15.70.20
!Date: Thursday, April 18, 2024 10:47:56
!Correction: S33(C  2-Port  )
!S43(C  2-Port  )
!S34(C  2-Port  )
!S44(C  2-Port  )
!S2P File: Measurements: S33, S43, S34, S44:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -42.16 dB at 38.77 GHz (marker M1); lowest = -110.9 dB at 17.25 GHz (marker M2)
!   lowest |S11| = -39.9 dB at 25.6 GHz (marker M3), VSWR 1.02, Z = 50.5 - j0.903 ohm
!   |S11| at or under -10 dB: 8.413 GHz to 10.6 GHz (2.186 GHz wide, 23 % of centre); 12.04 GHz to 14.73 GHz (2.684 GHz wide, 20 % of centre); 16.21 GHz to 17.38 GHz (1.167 GHz wide, 6.95 % of centre) (the widest 3 of 14)
!   |S22| runs from -31.1 to 1.4 dB; largest |S21 - S12| = 0.009
!   the Smith chart shows 24.19 GHz to 27.25 GHz only
!   S11 on the Smith chart (normalised r, x): 24.19 GHz: 1.14, +0.18; 24.83 GHz: 1.14, -0.92; 26.1 GHz: 0.78, -0.95; 26.76 GHz: 1.73, -0.49; 27.25 GHz: 0.52, -0.61
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.5  -65.5  -63.4  -0.3
! 6.68 GHz  -4.9  -71.1  -75.6  -1.2
! 10 GHz  -22.2  -83.8  -67.6  -1.2
! 11.91 GHz  -9.1  -61.9  -70.9  -1.7
! 13.34 GHz  -28.7  -75.2  -68.6  -4.1
! 14.96 GHz  -7.6  -80.7  -65.8  -2.7
! 15.59 GHz  -25.0  -66.3  -79.2  -3.2
! 17.25 GHz  -15.9  -110.9  -66.8  -7.7
! 18.95 GHz  -3.8  -71.3  -74.0  -24.2
! 20.01 GHz  -5.7  -59.1  -57.6  -8.0
! 21.92 GHz  -23.1  -62.0  -67.5  -2.4
! 24.19 GHz  -19.5  -59.2  -63.9  -3.7
! 24.83 GHz  -8.0  -71.5  -59.3  0.2
! 25.6 GHz  -39.9  -67.5  -58.9  -4.7
! 26.1 GHz  -6.3  -62.4  -62.0  -0.7
! 26.67 GHz  -6.6  -65.6  -57.5  -4.4
! 26.76 GHz  -10.0  -64.6  -62.1  -2.6
! 27.25 GHz  -6.5  -50.8  -59.1  -2.7
! 33.34 GHz  -2.2  -58.5  -62.5  -2.7
! 34.92 GHz  -3.7  -51.4  -62.2  -20.9
! 38.77 GHz  0.5  -42.2  -56.3  -3.2
! 40 GHz  0.7  -59.8  -51.4  -3.3
