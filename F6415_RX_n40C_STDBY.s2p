!Keysight Technologies,N5245B,MY52451815,A.15.70.20
!Date: Wednesday, April 17, 2024 15:37:56
!Correction: S33(C  2-Port  )
!S43(C  2-Port  )
!S34(C  2-Port  )
!S44(C  2-Port  )
!S2P File: Measurements: S33, S43, S34, S44:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -36.13 dB at 38.32 GHz (marker M1); lowest = -99.3 dB at 1.3 GHz (marker M2)
!   lowest |S11| = -38.1 dB at 21.1 GHz (marker M3), VSWR 1.03, Z = 49.6 - j1.16 ohm
!   |S11| at or under -10 dB: 18.91 GHz to 19.03 GHz (119 MHz wide, 0.627 % of centre); 19.95 GHz to 20.66 GHz (706.5 MHz wide, 3.48 % of centre); 20.74 GHz to 21.31 GHz (568.5 MHz wide, 2.7 % of centre)
!   |S22| runs from -31.6 to 1.3 dB; largest |S21 - S12| = 0.019
!   the Smith chart shows 18.44 GHz to 23.78 GHz only
!   S11 on the Smith chart (normalised r, x): 18.44 GHz: 0.30, +0.56; 19.78 GHz: 0.80, +0.90; 20.77 GHz: 1.32, -0.68; 21.61 GHz: 0.22, +0.04; 22.58 GHz: 0.31, +0.16; 23.78 GHz: 0.16, +0.16
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.4  -53.0  -52.7  -0.6
! 1.3 GHz  -0.5  -99.3  -71.1  -0.8
! 6.68 GHz  -1.0  -71.6  -65.2  -4.8
! 13.34 GHz  -1.4  -63.7  -67.2  -26.5
! 14.96 GHz  -3.3  -62.3  -70.8  -7.6
! 15.61 GHz  -2.3  -62.1  -63.2  -26.9
! 18.44 GHz  -3.9  -68.6  -62.2  -11.3
! 19.78 GHz  -6.7  -54.2  -68.9  -7.9
! 20.01 GHz  -11.9  -55.6  -61.0  -4.7
! 20.77 GHz  -10.2  -61.0  -59.9  -15.1
! 21.1 GHz  -38.1  -58.4  -61.9  -7.6
! 21.61 GHz  -3.8  -57.7  -53.9  -8.7
! 21.95 GHz  -2.6  -51.5  -57.3  -27.4
! 22.58 GHz  -5.5  -72.2  -60.1  -8.9
! 23.12 GHz  -1.1  -69.1  -62.6  -24.8
! 23.78 GHz  -2.8  -60.8  -60.5  -9.7
! 24.34 GHz  -1.1  -65.9  -72.1  -30.1
! 24.91 GHz  -0.9  -60.0  -56.9  -8.1
! 26.67 GHz  -1.3  -50.5  -49.2  -6.9
! 33.34 GHz  -2.0  -56.1  -51.3  -2.5
! 38.32 GHz  0.3  -36.1  -44.3  -0.3
! 40 GHz  1.4  -46.7  -51.9  0.8
