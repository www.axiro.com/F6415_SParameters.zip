!Keysight Technologies,N5245B,MY52451815,A.15.70.20
!Date: Thursday, April 18, 2024 10:07:22
!Correction: S33(C  2-Port  )
!S43(C  2-Port  )
!S34(C  2-Port  )
!S44(C  2-Port  )
!S2P File: Measurements: S33, S43, S34, S44:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -43.22 dB at 38.9 GHz (marker M1); lowest = -106.5 dB at 2.69 GHz (marker M2)
!   lowest |S11| = -48.3 dB at 25.55 GHz (marker M3), VSWR 1.01, Z = 50.4 + j0.0867 ohm
!   |S11| at or under -10 dB: 8.393 GHz to 10.5 GHz (2.112 GHz wide, 22.3 % of centre); 12.04 GHz to 14.67 GHz (2.627 GHz wide, 19.7 % of centre); 16.32 GHz to 17.36 GHz (1.041 GHz wide, 6.18 % of centre) (the widest 3 of 15)
!   |S22| runs from -53.8 to 0.8 dB; largest |S21 - S12| = 0.01
!   the Smith chart shows 24.32 GHz to 27.02 GHz only
!   S11 on the Smith chart (normalised r, x): 24.32 GHz: 0.88, -0.04; 24.84 GHz: 1.14, -0.95; 25.42 GHz: 1.29, +0.09; 25.93 GHz: 0.66, -0.66; 26.49 GHz: 1.58, -1.31; 27.02 GHz: 0.80, -0.33
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.6  -56.7  -61.5  -0.5
! 790 MHz  -0.8  -76.4  -81.3  -0.6
! 2.69 GHz  -1.4  -106.5  -79.2  -1.0
! 6.68 GHz  -5.4  -83.0  -83.3  -1.4
! 13.34 GHz  -28.7  -64.3  -68.0  -4.6
! 18.86 GHz  -5.0  -69.3  -75.0  -21.3
! 20.01 GHz  -7.0  -71.1  -65.6  -7.9
! 21.48 GHz  -10.8  -72.7  -70.1  -0.4
! 21.92 GHz  -25.6  -65.3  -73.2  -3.3
! 22.39 GHz  -11.8  -69.6  -66.6  -1.1
! 24.32 GHz  -23.2  -62.2  -59.6  -9.1
! 24.84 GHz  -7.8  -64.7  -59.0  0.4
! 25.42 GHz  -17.6  -55.2  -67.0  -14.5
! 25.55 GHz  -48.3  -60.0  -59.8  -6.0
! 25.93 GHz  -7.7  -64.0  -62.8  -0.1
! 26.49 GHz  -6.1  -62.6  -72.2  -11.1
! 26.67 GHz  -8.5  -62.7  -56.0  -3.8
! 27.02 GHz  -13.4  -63.0  -62.2  -1.2
! 33.34 GHz  -2.8  -56.1  -58.1  -3.3
! 34.85 GHz  -2.7  -54.8  -56.6  -39.3
! 38.9 GHz  -1.7  -43.2  -45.7  -1.2
! 40 GHz  0.8  -64.5  -46.9  -2.4
