!Keysight Technologies,N5245B,MY52451815,A.15.70.20
!Date: Wednesday, April 17, 2024 16:11:37
!Correction: S33(C  2-Port  )
!S43(C  2-Port  )
!S34(C  2-Port  )
!S44(C  2-Port  )
!S2P File: Measurements: S33, S43, S34, S44:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -32.10 dB at 39.06 GHz (marker M1); lowest = -97.0 dB at 3.11 GHz (marker M2)
!   lowest |S11| = -13.6 dB at 19.07 GHz (marker M3), VSWR 1.53, Z = 40.1 + j16.5 ohm
!   |S11| at or under -10 dB: 18.82 GHz to 20.03 GHz (1.206 GHz wide, 6.21 % of centre); 20.71 GHz to 21.01 GHz (298.5 MHz wide, 1.43 % of centre)
!   |S22| runs from -63.9 to 2.7 dB; largest |S21 - S12| = 0.027
!   the Smith chart shows 15.97 GHz to 21.89 GHz only
!   S11 on the Smith chart (normalised r, x): 15.97 GHz: 0.18, -0.47; 17.21 GHz: 0.16, -0.09; 18.48 GHz: 0.26, +0.20; 19.68 GHz: 0.62, +0.32; 20.8 GHz: 0.72, -0.37; 21.89 GHz: 0.16, -0.22
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.5  -57.9  -57.7  -0.8
! 3.11 GHz  -1.0  -97.0  -71.0  -1.3
! 6.68 GHz  -1.3  -66.9  -69.0  -6.0
! 13.34 GHz  -3.4  -71.9  -58.7  -20.6
! 14.32 GHz  -2.4  -59.6  -60.4  -32.6
! 14.95 GHz  -5.3  -56.7  -58.0  -7.4
! 15.56 GHz  -1.7  -59.5  -61.1  -32.1
! 15.97 GHz  -2.5  -57.7  -61.5  -9.3
! 17.21 GHz  -2.8  -62.4  -67.7  -12.0
! 18.48 GHz  -4.4  -51.1  -63.5  -8.9
! 19.07 GHz  -13.6  -50.8  -61.2  -5.0
! 19.68 GHz  -10.5  -54.5  -58.9  -10.6
! 20.01 GHz  -10.1  -50.5  -57.1  -5.3
! 20.8 GHz  -11.5  -61.7  -52.2  -21.3
! 21.34 GHz  -4.7  -58.3  -57.8  -7.5
! 21.89 GHz  -2.7  -62.5  -56.0  -22.3
! 24.92 GHz  -2.1  -53.8  -54.3  -8.1
! 25.52 GHz  -0.9  -62.8  -50.3  -35.0
! 26.67 GHz  -3.0  -46.5  -45.3  -8.3
! 33.34 GHz  -4.5  -47.9  -44.7  -2.0
! 39.06 GHz  -1.0  -32.1  -49.2  -5.5
! 40 GHz  0.4  -49.8  -44.4  1.6
