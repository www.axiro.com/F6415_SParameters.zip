!Keysight Technologies,N5245B,MY52451815,A.15.70.20
!Date: Wednesday, April 17, 2024 14:31:38
!Correction: S33(C  2-Port  )
!S43(C  2-Port  )
!S34(C  2-Port  )
!S44(C  2-Port  )
!S2P File: Measurements: S33, S43, S34, S44:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -34.99 dB at 38.8 GHz (marker M1); lowest = -101.5 dB at 540 MHz (marker M2)
!   lowest |S11| = -13.3 dB at 19.94 GHz (marker M3), VSWR 1.56, Z = 32.7 + j4.84 ohm
!   |S11| at or under -10 dB: 18.9 GHz to 19.25 GHz (347.5 MHz wide, 1.82 % of centre); 19.68 GHz to 20.28 GHz (601.3 MHz wide, 3.01 % of centre); 20.77 GHz to 21.06 GHz (290.8 MHz wide, 1.39 % of centre)
!   |S22| runs from -38.5 to 2.3 dB; largest |S21 - S12| = 0.032
!   the Smith chart shows 16.93 GHz to 22.85 GHz only
!   S11 on the Smith chart (normalised r, x): 16.93 GHz: 0.11, -0.03; 18.3 GHz: 0.19, +0.31; 19.54 GHz: 0.75, +0.59; 20.47 GHz: 0.64, -0.55; 21.58 GHz: 0.17, -0.13; 22.85 GHz: 0.07, +0.06
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.5  -44.3  -43.2  -0.7
! 540 MHz  -0.2  -101.5  -69.5  -0.7
! 6.68 GHz  -1.2  -89.0  -79.0  -5.4
! 13.34 GHz  -2.8  -57.6  -58.7  -23.9
! 14.94 GHz  -4.7  -63.9  -63.8  -7.3
! 15.55 GHz  -1.6  -61.2  -60.4  -34.4
! 16.12 GHz  -3.0  -53.6  -56.4  -9.0
! 16.93 GHz  -1.9  -60.9  -57.7  -17.4
! 18.3 GHz  -3.1  -51.5  -55.3  -14.2
! 19.54 GHz  -9.2  -59.1  -65.6  -12.3
! 19.94 GHz  -13.3  -62.1  -61.0  -5.4
! 20.01 GHz  -12.6  -57.3  -69.7  -4.9
! 20.47 GHz  -8.4  -61.6  -65.7  -7.6
! 21.58 GHz  -3.0  -53.6  -60.5  -9.1
! 21.94 GHz  -2.6  -50.7  -65.9  -31.9
! 22.85 GHz  -1.2  -54.8  -59.9  -14.0
! 25 GHz  -1.8  -66.8  -62.7  -8.2
! 25.56 GHz  -0.6  -58.7  -57.4  -38.5
! 26.67 GHz  -2.6  -62.1  -54.8  -7.7
! 33.34 GHz  -3.4  -50.7  -45.6  -2.0
! 38.8 GHz  -0.5  -35.0  -45.0  0.3
! 40 GHz  0.5  -48.3  -52.2  1.2
